# Keil uVision project NRF_Car_TEST.uvproj, settings and files
target NRF_CAR_MASTER (MCS-51)
  device: STC15W408AS STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: NRF_CAR_MASTER +hex
  c flags: SizeSpeed=1
  c define: STC_Y5, FOSC = 11059200L, UART_BAUD = 115200, UART_PARITYBIT = ODD_PARITY, TEST_MODE = 1, NRF_CAR_MASTER , ROCKER_SUM = 1
  c include: ..\USER;..\Version;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\timer;..\SYSTEM\spi;..\SYSTEM\adc;..\SYSTEM\pca;..\HARDWARE\NRF24L01;..\HARDWARE\Rocker;..\APP;..\APP\NRF_DT
  group APP
    ../APP/NRF_DT/: NRF_DT.c
  group HARDWARE
    ../HARDWARE/NRF24L01/: NRF24L01.c
    ../HARDWARE/Rocker/: Rocker.c
  group SYSTEM
    ./: STARTUP.A51
    ../SYSTEM/: STC15.H SYS.H
    ../SYSTEM/delay/: delay.h delay.c
    ../SYSTEM/uart/: uart.h uart.c
    ../SYSTEM/timer/: timer.h timer.c
    ../SYSTEM/spi/: spi.h spi.c
    ../SYSTEM/adc/: adc.h adc.c
    ../SYSTEM/eeprom/: eeprom.h eeprom.c
    ../SYSTEM/pca/: pca.h pca.c
  group USER
    ./: MAIN.c
  group VERSION
    ../Version/: Version.c Version list.txt
target NRF_CAR_SLAVE (MCS-51)
  device: STC15W408AS STC
  cpu: as above
  output: NRF_CAR_SLAVE +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: STC_Y5, FOSC = 11059200L, UART_BAUD = 115200, UART_PARITYBIT = ODD_PARITY, TEST_MODE = 1, NRF_CAR_SLAVE , ROCKER_SUM = 1
  c include: ..\USER;..\SYSTEM;..\SYSTEM\delay;..\SYSTEM\uart;..\SYSTEM\adc;..\SYSTEM\eeprom;..\SYSTEM\timer;..\SYSTEM\pca;..\SYSTEM\spi;..\HARDWARE\NRF24L01;..\HARDWARE\Rocker;..\APP\NRF_DT
